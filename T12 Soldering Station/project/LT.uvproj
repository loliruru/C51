# Keil uVision project LT.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C2052AD Series STC
  cpu: IRAM(0-0xFF) IROM(0-0x7FF) CLOCK(45000000)
  output: LT +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\SRC
  group Source Group 1
    ../SRC/: main.c oled.c
